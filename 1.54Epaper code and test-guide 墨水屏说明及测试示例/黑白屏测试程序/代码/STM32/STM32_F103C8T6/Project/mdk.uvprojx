# Keil uVision project mdk.uvprojx, settings and files
target GDE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mdk +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,GDEP015OC1
  c include: ..\FWLib;..\User;..\StartUp;..\EPD_W21
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FwLib
    ../FWLib/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c misc.c stm32f10x_iwdg.c
  group StartUp
    ../StartUp/: system_stm32f10x.c core_cm3.c stm32f10x_conf.h startup_stm32f10x_hd.s
  group User
    ../User/: stm32f10x_it.c main.c
  group EPD_W21
    ../EPD_W21/: Display_EPD_W21_Aux.c Display_EPD_W21.c
software components: CMSIS:CORE 4.1.0
